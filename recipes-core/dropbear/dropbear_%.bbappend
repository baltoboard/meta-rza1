FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://loginrec.h.patch"
